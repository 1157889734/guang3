# IAR project JoyStickMouse.ewp, settings and files
configuration STM32108PKT (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32F10xx6 ST STM32F10xx6
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: ..\inc; ..\..\Libraries\STM32_USB-FS-Device_Driver\inc; ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\Libraries\STM32_USB-FS-Device_Driver\inc; ..\..\Libraries\CMSIS\Core\CM3
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: G3_Bcu_p2pV1.6.bin
  ILINK.IlinkOutputFile: AudioSpeaker.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../Libraries/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
  group Doc
    ../: readme.txt
  group EWARMv5
    ../../Libraries/CMSIS/Core/CM3/startup/iar/: startup_stm32f10x_md_vl.s
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_usart.c
  group User
    ../src/: data_box.c data_public.c data_train.c device_info.c esu.c flash_if.c hw_config.c led_control.c main.c progupdate.c set_vlum.c stat_switch.c stm32f10x_it.c systick.c uart1.c uart2.c
