# Keil uVision project ATC.uvproj, settings and files
target ATC (ARM-ADS)
  device: STM32F207ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: SZ1-ATC
  AfterMake: fromelf --bin --output .\bin\GZ-3-1.1.bin .\out\SZ1-ATC.axf
  c flags: Optim=2
  c define: USE_STM322xG_EVAL, STM32F2XX, USE_STDPERIPH_DRIVER
  c include: .\stm32\CMSIS\CM3\CoreSupport;.\stm32\lwip_v1.3.2\src\core\ipv4;.\stm32\lwip_v1.3.2\port\STM32F2x7\arch;.\stm32\STM32_EVAL\Common;.\stm32\STM32_EVAL\STM322xG_EVAL;.\stm32\STM32_EVAL;.\stm32\STM32_USB_Device_Library\Core\inc;.\stm32\STM32_USB_Device_Library\Class\msc\inc;.\stm32\STM32_USB_Device_Library\Class\hid\inc;.\stm32\STM32_USB_Device_Library\Class\dfu\inc;.\stm32\STM32_USB_Device_Library\Class\cdc\inc;.\stm32\STM32_USB_OTG_Driver\inc;.\stm32\STM32F2x7_ETH_Driver\inc;.\stm32\STM32F2xx_StdPeriph_Driver\inc;.\user\inc;.\user\FatFs;.\user\FatFs\option;.\stm32\lwip_v1.3.2\src\include;.\stm32\lwip_v1.3.2\port\STM32F2x7;.\stm32\lwip_v1.3.2\src\include\lwip;.\stm32\lwip_v1.3.2\src\include\ipv4;.\stm32\lwip_v1.3.2\port\STM32F2x7\Standalone
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group startup
    ./startup/: startup_stm32f2xx.s
  group USER
    ./user/src/: cmd.c common.c flash_if.c main.c rtc_1337.c sd_data.c stm32f2xx_it.c system_stm32f2xx.c tba_bus.c tcms.c uart.c usb.c usb_bsp.c usbd_desc.c usbd_usr.c
  group STM32
    ./stm32/STM32F2xx_StdPeriph_Driver/src/: stm32f2xx_usart.c misc.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_gpio.c stm32f2xx_iwdg.c stm32f2xx_rcc.c stm32f2xx_sdio.c stm32f2xx_syscfg.c stm32f2xx_i2c.c stm32f2xx_rtc.c stm32f2xx_pwr.c
  group fatfs
    ./user/FatFs/: ff.c
    ./user/src/: diskio.c
  group usb
    ./stm32/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ./stm32/STM32_USB_OTG_Driver/src/: usb_dcd_int.c usb_core.c usb_dcd.c
    ./stm32/STM32_USB_Device_Library/Class/hid/src/: usbd_hid_core.c
  group CMSIS
    ./stm32/CMSIS/CM3/CoreSupport/: core_cm3.c
  group stm32_eval
    ./stm32/STM32_EVAL/Common/: stm32_eval_sdio_sd.c
    ./stm32/STM32_EVAL/: stm32_eval.c
  group LWip
    ./stm32/lwip_v1.3.2/src/core/: mem.c memp.c
