# Keil uVision project UART1-UART2.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8052AH Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: box_p2p +hex
  c flags: Optimize=1 SizeSpeed=1
  group Source Group 1
    ./: USART.C main.c delay.c com.c led_control.c stat_switch.c timer.c key.c 2com.c
