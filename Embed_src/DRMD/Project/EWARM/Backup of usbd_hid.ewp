# IAR project Backup of usbd_hid.ewp, settings and files
configuration STM322xG-EVAL_USBD-HS (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: usbd_msc.srec
  ILINK.IlinkOutputFile: usbd_hid.out
configuration STM322xG-EVAL_USBD-FS (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F207xx ST STM32F207xx
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX; USE_STM322xG_EVAL
  ICCARM.CCIncludePath2: ..\inc; ..\..\Utilities\STM32_EVAL; ..\..\Utilities\STM32_EVAL\STM322xG_EVAL; ..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc; ..\..\Libraries\STM32F2x7_ETH_Driver\inc; ..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx; ..\..\Utilities\Third_Party\lwip_v1.3.2\port\; ..\..\Utilities\Third_Party\lwip_v1.3.2\port\STM32F2x7; ..\..\Utilities\Third_Party\lwip_v1.3.2\src\include; ..\..\Utilities\Third_Party\lwip_v1.3.2\src\include\ipv4; ..\..\Utilities\Third_Party\lwip_v1.3.2\src\include\lwip; ..\..\Utilities\Third_Party\lwip_v1.3.2\port\STM32F2x7\Standalone; ..\..\Utilities\efsl\include; ..\..\Utilities\efsl\include\interface; ..\..\Utilities\STM32_EVAL\Common; ..\..\Utilities\Third_Party\FatFs_vR0.08a; ..\..\Libraries\STM32_USB_OTG_Driver\inc; ..\..\libraries\stm32_usb_device_library\class\hid\inc; ..\..\Libraries\STM32_USB_Device_Library\Class\msc\inc; ..\..\Libraries\STM32_USB_Device_Library\Class\cdc\inc; ..\..\Libraries\STM32_USB_Device_Library\Core\inc
  ICCARM.CCOptLevel: 0
  OBJCOPY.OOCOutputFile: usbd_hid.bin
  ILINK.IlinkIcfFile: E:\project\伊朗\前部外侧屏\project\Project\EWARM\stm32f2xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM3210C-EVAL_USBD-FS (ARM, debug)
  as the first configuration, except:
  group App
    ../src/: at45db161.c com_proc.c common.c Debug.c DeviceId.c flash_if.c httpserver.c LedDrv.c main.c netconf.c sd_data.c stm32f2x7_eth_bsp.c stm32f2xx_it.c system_stm32f2xx.c tba_3093.c tba_3093_422_1.c tba_3093_422_2.c telnet.c tftpserver.c uart1.c uart2.c uart3.c uart4.c udp_server.c usb.c usb_bsp.c usbd_desc.c usbd_usr.c utils.c
  group CMSIS
    ../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group EWARMv5
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/startup/iar/: startup_stm32f2xx.s
  group FatFs
    ../src/: diskio.c
    ../../Utilities/Third_Party/FatFs_vR0.08a/: ff.c
  group LwIP/CORE
    ../../Utilities/Third_Party/lwip_v1.3.2/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group LwIP/CORE/IPv4
    ../../Utilities/Third_Party/lwip_v1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group LwIP/Netif
    ../../Utilities/Third_Party/lwip_v1.3.2/src/netif/: etharp.c
    ../../Utilities/Third_Party/lwip_v1.3.2/port/STM32F2x7/Standalone/: ethernetif.c
  group STM32_EVAL
    ../../Utilities/STM32_EVAL/: stm32_eval.c
    ../../Utilities/STM32_EVAL/Common/: stm32_eval_sdio_sd.c
  group STM32F2xx_ETH_Driver
    ../../Libraries/STM32F2x7_ETH_Driver/src/: stm32f2x7_eth.c
  group STM32F2xx_StdPeriph_Driver
    ../../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_gpio.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_usart.c
  group USB Device/Class/HID
    ../../Libraries/STM32_USB_Device_Library/Class/hid/src/: usbd_hid_core.c
  group USB Device/Library
    ../../Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group USB Drivers
    ../../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
