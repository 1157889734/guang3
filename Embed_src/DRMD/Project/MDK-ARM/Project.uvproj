# Keil uVision project Project.uvproj, settings and files
target STM322xG_EVAL (ARM-ADS)
  device: STM32F207ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM322xG_EVAL
  AfterMake: fromelf --bin --output .\binary\IDU.bin .\STM322xG_EVAL\STM322xG_EVAL.axf
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F2XX,USE_STM322xG_EVAL
  c include: ..\inc;..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx;..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\..\Libraries\STM32F2x7_ETH_Driver\inc;..\..\Utilities\STM32_EVAL;..\..\Utilities\STM32_EVAL\Common;..\..\Utilities\STM32_EVAL\STM322xG_EVAL;..\..\Utilities\Third_Party\lwip_v1.3.2\src\include;..\..\Utilities\Third_Party\lwip_v1.3.2\src\include\lwip;..\..\Utilities\Third_Party\lwip_v1.3.2\src\include\netif;..\..\Utilities\Third_Party\lwip_v1.3.2\src\include\ipv4;..\..\Utilities\Third_Party\lwip_v1.3.2\port\STM32F2x7;..\..\Utilities\Third_Party\lwip_v1.3.2\port\STM32F2x7\Standalone;..\..\Utilities\Third_Party\FreeRTOS_v6.1.0\portable\EWARM\ARM_CM3;..\..\Utilities\Third_Party\FreeRTOS_v6.1.0\include;..\..\Utilities\STM32_EVAL\Common;..\..\Utilities\Third_Party\FatFs_vR0.08a\option;..\..\Libraries\STM32_USB_Device_Library\Class\hid\inc;..\..\Libraries\STM32_USB_Device_Library\Core\inc;..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\Utilities\Third_Party\FatFs_vR0.08a
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ../src/: system_stm32f2xx.c
    ../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group MDK-ARM
    ./: startup_stm32f2xx.s
  group User
    ../src/: tftpserver.c flash_if.c httpserver.c main.c netconf.c stm32f2x7_eth_bsp.c stm32f2xx_it.c
  group LwIP
    ../../Utilities/Third_Party/lwip_v1.3.2/src/api/: tcpip.c api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c
    ../../Utilities/Third_Party/lwip_v1.3.2/src/core/ipv4/: ip_frag.c autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c
    ../../Utilities/Third_Party/lwip_v1.3.2/src/core/: udp.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c
    ../../Utilities/Third_Party/lwip_v1.3.2/src/netif/: etharp.c
    ../../Utilities/Third_Party/lwip_v1.3.2/port/STM32F2x7/Standalone/: ethernetif.c
  group STM32F2xx_StdPeriph_Driver
    ../../Libraries/STM32F2xx_StdPeriph_Driver/src/: stm32f2xx_sdio.c stm32f2xx_syscfg.c stm32f2xx_usart.c misc.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_i2c.c stm32f2xx_rcc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_spi.c stm32f2xx_tim.c stm32f2xx_wwdg.c
  group STM32F2x7_ETH_Driver
    ../../Libraries/STM32F2x7_ETH_Driver/src/: stm32f2x7_eth.c
  group STM322xG_EVAL
    ../../Utilities/STM32_EVAL/: stm32_eval.c
    ../../Utilities/STM32_EVAL/STM322xG_EVAL/: stm322xg_eval_lcd.c
  group add_src
    ../../Libraries/STM32_USB_Device_Library/Class/hid/src/: usbd_hid_core.c
    ../../Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../../Libraries/STM32_USB_OTG_Driver/src/: usb_dcd.c usb_dcd_int.c usb_core.c
    ../../Utilities/STM32_EVAL/Common/: stm32_eval_sdio_sd.c
    ../../Utilities/Third_Party/FatFs_vR0.08a/: ff.c
  group src
    ../src/: at45db161.c com_proc.c common.c Debug.c DeviceId.c diskio.c fsdata.c LedDrv.c sd_data.c tba_3093.c tba_3093_422_1.c tba_3093_422_2.c telnet.c uart1.c uart2.c uart3.c uart4.c udp_server.c usb.c usb_bsp.c usbd_desc.c usbd_usr.c utils.c
