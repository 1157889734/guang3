# Keil uVision project TBA-2476SZ1-26.uvproj, settings and files
target TBA-2476SZ1-26 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(24000000)
  output: TBA-2476SZ1-26 +hex
  c flags: Optimize=8 SizeSpeed=1
  group APP
    ./: TBA-2476SZ1-26.c
