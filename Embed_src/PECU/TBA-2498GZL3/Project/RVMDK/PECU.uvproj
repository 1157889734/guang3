# Keil uVision project PECU.uvproj, settings and files
target PECU (ARM-ADS)
  device: ISD9160 Nuvoton
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x233FF) CLOCK(49152000) CPUTYPE("Cortex-M0")
  output: TBA-2498GZL3 +hex
  c flags: Optim=1 OneElfS=1
  c include: ..\inc;..\..\ISD91XX_SDK\CMSIS\CM0\CoreSupport;..\..\ISD91XX_SDK\CMSIS\CM0\DeviceSupport\Nuvoton\ISD91xx;..\..\ISD91XX_SDK\NuvotonPlatform_Keil\Include\Driver;..\..\ISD91XX_SDK\NuvotonPlatform_Keil\Include
  memory RVCT4: ROM 0x0 size 0x23400
  memory RVCT9: RAM 0x20000000 size 0x3000
  link misc: --map --first='startup_ISD91xx.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group User
    ../src/: main.c uart.c hw_config.c timer.c playPCM.c play_ctrl.c audio_file.c pecu.c
  group RVMDK
    ../../ISD91XX_SDK/CMSIS/CM0/DeviceSupport/Nuvoton/ISD91xx/startup/arm/: startup_ISD91xx.s
  group CMSIS
    ../../ISD91XX_SDK/CMSIS/CM0/CoreSupport/: core_cm0.c
    ../../ISD91XX_SDK/CMSIS/CM0/DeviceSupport/Nuvoton/ISD91xx/: system_ISD9xx.c
  group ISD9160_Lib
    ../../ISD91XX_SDK/NuvotonPlatform_Keil/Src/Driver/: retarget.c DrvGPIO.c DrvSYS.c DrvUART.c DrvTimer.c DrvPDMA.c DrvDPWM.c
