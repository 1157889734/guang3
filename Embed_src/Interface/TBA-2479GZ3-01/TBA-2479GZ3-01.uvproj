# Keil uVision project TBA-2479GZ3-01.uvproj, settings and files
target TBA-2479GZ3-01 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(24000000)
  output: TBA-2479GZ3-01 +hex
  c flags: Optimize=8 SizeSpeed=1
  group APP
    ./: TBA-2479GZ3-01.c
